Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: cce0d8b4-e3de-4a18-b06f-14a5d32f5459, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-11T04:05:46+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11905920_AUS_TWR780WP_LW:12WR7802_AUS_11905920_TWR780WP_LW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Orange, <Unnamed>, z_Miele_Design_Powder Coat_Lotus White, z_Miele_Design_Glass, z_Miele_Design_Steel_Hight_Gloss_Chrom, z_Miele_Design_Glass Black, z_Miele_Connection_Water_OUT, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 596 mm; Height: 850 mm; Depth: 643 mm
Classification: E1010610 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 12WR7802_AUS_11905920_TWR780WP_LW; sets with these values: 2

# IfcDistributionPort, Port_360235_1
Description: Flow; FlowDirection: SOURCEANDSINK
